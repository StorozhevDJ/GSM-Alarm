# IAR project gsm_alarm_v1.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F100x8 ST STM32F100x8
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER
  ICCARM.PreInclude: stm32F10x.h
  ICCARM.CCIncludePath2: ; inc\; Libraries\STM32F10x_StdPeriph_Driver\inc\; Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x\; Libraries\CMSIS\CM3\CoreSupport\; Lib\
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 1
  OBJCOPY.OOCOutputFile: gsm_alarm_v1.bin
  ILINK.IlinkOutputFile: c.out
  ILINK.IlinkIcfFile: stm32f10x_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: default None
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: c.srec
  group (top)
    ./: main.c
  group inc
    ./: main.h
    inc/: MyGSM.h SMS_protocol.h
  group Libraries/1Wire
    Lib/1Wire/: 1wire.c 1wire.h
  group Libraries/EE_emul
    Lib/EE_emul/: eeprom.c eeprom.h
  group Libraries/GSM_GPRS
    Lib/GSM/: NewSoftSerial.cpp
  group Libraries/GSM_GPRS/GSM
    Lib/GSM/: GSM_Shield.cpp
  group Libraries/GSM_GPRS/GSM_GPRS_SIM900/inc
    Lib/GSM_GPRS/: call.h GSM.h inetGSM.h LOG.h SIM900.h sms.h Streaming.h WideTextFinder.h
  group Libraries/GSM_GPRS/GSM_GPRS_SIM900/src
    Lib/GSM_GPRS/: call.cpp GSM.cpp inetGSM.cpp LOG.cpp SIM900.cpp sms.cpp WideTextFinder.cpp
  group Libraries/iButton
    Lib/iButton/: iButton.c iButton.h
  group Libraries/PDU
    Lib/PDU/: Pdu.c Pdu.h
  group Libraries/Print_scan
    Lib/Print_scan/: Parser.cpp Print.cpp Print.hpp
    Lib/Print_Scan/: Parser.h
  group Libraries/RTC
    Lib/RTC/: rtc.c rtc.h
  group Libraries/STM32
    Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/iar/: startup_stm32f10x_ld_vl.s
    inc/: stm32f10x_conf.h stm32f10x_it.h
    src/: stm32f10x_it.c system_stm32f10x.c
  group Libraries/STM32/inc
    Libraries/STM32F10x_StdPeriph_Driver/inc/: misc.h stm32f10x_adc.h stm32f10x_bkp.h stm32f10x_can.h stm32f10x_cec.h stm32f10x_crc.h stm32f10x_dac.h stm32f10x_dbgmcu.h stm32f10x_dma.h stm32f10x_exti.h stm32f10x_flash.h stm32f10x_fsmc.h stm32f10x_gpio.h stm32f10x_i2c.h stm32f10x_iwdg.h stm32f10x_pwr.h stm32f10x_rcc.h stm32f10x_rtc.h stm32f10x_sdio.h stm32f10x_spi.h stm32f10x_tim.h stm32f10x_usart.h stm32f10x_wwdg.h
  group Libraries/STM32/src
    Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group src
    src/: In_Out.c MyGSM.c SMS_protocol.c
